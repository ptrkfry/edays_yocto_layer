IMAGE_INSTALL_append = " cmake_recipe_helloworld"
